# Keil uVision project proj.uvprojx, settings and files
target X-Track (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: -AT32F403ACGU7 ArteryTek
  pack: ArteryTek.AT32F403A_407_DFP.2.1.1
  cpu: IRAM(0x20000000,0x38000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: X-Track +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: LIBRARY_VERSION,ARDUINO=111
  c misc: --gnu
  c include: ..\ArduinoAPI;..\Core;..\Libraries;..\USER;..\Libraries\SdFat\src;..\Simulator\LVGL.Simulator;..\USER\App;..\Libraries\AT32F4xx_StdPeriph_Driver\inc;..\Libraries\CMSIS\CM4\DeviceSupport;..\Libraries\CMSIS\CM4\CoreSupport
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group USER
    ../USER/: main.cpp
  group App
    ../USER/App/: Version.h App.cpp App.h
  group Config
    ../USER/App/Config/: Config.h
  group Common/DataPorc
    ../USER/App/Common/DataProc/: DP_LIST.inc DataProc.h DataProc.cpp DataProc_Def.h DP_Clock.cpp DP_GPS.cpp DP_Power.cpp DP_SportStatus.cpp DP_Recorder.cpp DP_IMU.cpp DP_MAG.cpp DP_Storage.cpp DP_MusicPlayer.cpp DP_TzConv.cpp DP_SysConfig.cpp DP_TrackFilter.cpp
  group Pages
    ../USER/App/Pages/: AppFactory.cpp AppFactory.h Page.h
  group Pages/StatusBar
    ../USER/App/Pages/StatusBar/: StatusBar.cpp StatusBar.h
  group Pages/StartUp
    ../USER/App/Pages/StartUp/: StartUp.cpp StartUp.h StartUpModel.cpp StartUpModel.h StartUpView.cpp StartUpView.h
  group Pages/Dialplate
    ../USER/App/Pages/Dialplate/: Dialplate.cpp Dialplate.h DialplateModel.cpp DialplateModel.h DialplateView.cpp DialplateView.h
  group Pages/LiveMap
    ../USER/App/Pages/LiveMap/: LiveMap.cpp LiveMap.h LiveMapModel.cpp LiveMapModel.h LiveMapView.cpp LiveMapView.h
  group Pages/SystemInfos
    ../USER/App/Pages/SystemInfos/: SystemInfos.cpp SystemInfos.h SystemInfosModel.cpp SystemInfosModel.h SystemInfosView.cpp SystemInfosView.h
  group Pages/_Template
    ../USER/App/Pages/_Template/: Template.cpp Template.h TemplateModel.cpp TemplateModel.h TemplateView.cpp TemplateView.h
  group Resource
    ../USER/App/Resource/: ResourcePool.cpp ResourcePool.h
  group Resource/Font
    ../USER/App/Resource/Font/: font_bahnschrift_13.c font_bahnschrift_17.c font_bahnschrift_32.c font_bahnschrift_65.c font_agencyb_36.c
  group Resource/Image
    ../USER/App/Resource/Image/: img_src_gps_arrow.c img_src_gps_pin.c img_src_alarm.c img_src_battery.c img_src_locate.c img_src_menu.c img_src_origin_point.c img_src_satellite.c img_src_stop.c img_src_trip.c img_src_pause.c img_src_start.c img_src_battery_info.c img_src_bicycle.c img_src_compass.c img_src_gyroscope.c img_src_map_location.c img_src_storage.c img_src_system_info.c img_src_time_info.c img_src_sd_card.c
  group Utils/lv_allocator
    ../USER/App/Utils/lv_allocator/: lv_allocator.h
  group Utils/lv_ext
    ../USER/App/Utils/lv_ext/: lv_label_anim_effect.cpp lv_obj_ext_func.cpp lv_anim_timeline_wrapper.c
  group Utils/MapConv
    ../USER/App/Utils/MapConv/: MapConv.cpp MapConv.h
  group Utils/PageManager
    ../USER/App/Utils/PageManager/: PageBase.h PageFactory.h PageManager.h PM_Anim.cpp PM_Base.cpp PM_Drag.cpp PM_Log.h PM_Router.cpp PM_State.cpp ResourceManager.cpp ResourceManager.h
  group Utils/DataCenter
    ../USER/App/Utils/DataCenter/: Account.cpp Account.h DataCenter.cpp DataCenter.h DataCenterLog.h
    ../USER/App/Utils/DataCenter/PingPongBuffer/: PingPongBuffer.c PingPongBuffer.h
  group Utils/Filters
    ../USER/App/Utils/Filters/: Filters.h FilterBase.h HysteresisFilter.h LowpassFilter.h MedianFilter.h MedianQueueFilter.h SlidingFilter.h
  group Utils/GPS_Transform
    ../USER/App/Utils/GPS_Transform/: GPS_Transform.c GPS_Transform.h
  group Utils/GPX
    ../USER/App/Utils/GPX/: GPX.cpp GPX.h
  group Utils/GPX_Parser
    ../USER/App/Utils/GPX_Parser/: GPX_Parser.cpp GPX_Parser.h
  group Utils/StorageService
    ../USER/App/Utils/StorageService/: StorageService.cpp StorageService.h
  group Utils/TileSystem
    ../USER/App/Utils/TileSystem/: TileSystem.cpp TileSystem.h
  group Utils/TonePlayer
    ../USER/App/Utils/TonePlayer/: TonePlayer.cpp TonePlayer.h
  group Utils/Time
    ../USER/App/Utils/Time/: DateStrings.cpp Time.cpp Time.h TimeLib.h
  group Utils/TrackFilter
    ../USER/App/Utils/TrackFilter/: TrackFilter.h TrackLineFilter.cpp TrackLineFilter.h TrackPointFilter.cpp TrackPointFilter.h
  group Utils/TileConv
    ../USER/App/Utils/TileConv/: TileConv.cpp TileConv.h
  group Display
    ../USER/Display/: Display.h Display.cpp DisplayFault.cpp
  group HAL
    ../USER/HAL/: HAL.h HAL.cpp HAL_Backlight.cpp HAL_Clock.cpp HAL_GPS.cpp HAL_I2C_Scan.cpp HAL_IMU.cpp HAL_MAG.cpp HAL_Power.cpp HAL_SD_CARD.cpp HAL_Buzz.cpp HAL_Encoder.cpp HAL_Audio.cpp
  group lvgl
    ../Simulator/LVGL.Simulator/: lv_conf.h
    ../Simulator/LVGL.Simulator/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../Simulator/LVGL.Simulator/lvgl/src/draw/: lv_draw_arc.c lv_draw_blend.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../Simulator/LVGL.Simulator/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../Simulator/LVGL.Simulator/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../Simulator/LVGL.Simulator/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../Simulator/LVGL.Simulator/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../Simulator/LVGL.Simulator/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../Simulator/LVGL.Simulator/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../Simulator/LVGL.Simulator/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../Simulator/LVGL.Simulator/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../Simulator/LVGL.Simulator/lvgl/src/extra/widgets/led/: lv_led.c
    ../Simulator/LVGL.Simulator/lvgl/src/extra/widgets/list/: lv_list.c
    ../Simulator/LVGL.Simulator/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../Simulator/LVGL.Simulator/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../Simulator/LVGL.Simulator/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../Simulator/LVGL.Simulator/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../Simulator/LVGL.Simulator/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../Simulator/LVGL.Simulator/lvgl/src/extra/widgets/win/: lv_win.c
    ../Simulator/LVGL.Simulator/lvgl/src/extra/: lv_extra.c
    ../Simulator/LVGL.Simulator/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../Simulator/LVGL.Simulator/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../Simulator/LVGL.Simulator/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../Simulator/LVGL.Simulator/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
    ../Simulator/LVGL.Simulator/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../Simulator/LVGL.Simulator/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../Simulator/LVGL.Simulator/lvgl/src/extra/widgets/span/: lv_span.c
    ../Simulator/LVGL.Simulator/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../Simulator/LVGL.Simulator/lvgl/src/extra/others/snapshot/: lv_snapshot.c
  group lv_examples
    ../Simulator/LVGL.Simulator/: lv_demo_conf.h
    ../Simulator/LVGL.Simulator/lv_examples/src/lv_demo_benchmark/: lv_demo_benchmark.c
    ../Simulator/LVGL.Simulator/lv_examples/src/lv_demo_keypad_encoder/: lv_demo_keypad_encoder.c
    ../Simulator/LVGL.Simulator/lv_examples/src/lv_demo_stress/assets/: lv_font_montserrat_12_compr_az.c lv_font_montserrat_16_compr_az.c lv_font_montserrat_28_compr_az.c
    ../Simulator/LVGL.Simulator/lv_examples/src/lv_demo_stress/: lv_demo_stress.c
    ../Simulator/LVGL.Simulator/lv_examples/src/lv_demo_widgets/assets/: img_clothes.c img_demo_widgets_avatar.c img_lvgl_logo.c
    ../Simulator/LVGL.Simulator/lv_examples/src/lv_demo_widgets/: lv_demo_widgets.c
    ../Simulator/LVGL.Simulator/lvgl/examples/assets/: img_cogwheel_alpha16.c img_cogwheel_argb.c img_cogwheel_chroma_keyed.c img_cogwheel_indexed16.c img_cogwheel_rgb.c
  group lv_port
    ../USER/Display/lv_port/: lv_port_disp.cpp lv_port_indev.cpp lv_fs_sdfat.cpp
  group Libraries
    ../Libraries/Adafruit_GFX_Library/: Adafruit_GFX.cpp
    ../Libraries/Adafruit_ST7789/: Adafruit_ST7789.cpp
    ../Libraries/LIS3MDL/: LIS3MDL.cpp
    ../Libraries/LSM6DSM/: LSM6DSM.cpp
    ../Libraries/TinyGPSPlus/src/: TinyGPS++.cpp
    ../Libraries/ButtonEvent/: ButtonEvent.cpp
    ../Libraries/StackInfo/: StackInfo.c
  group SdFat
    ../Libraries/SdFat/src/FatLib/: FatFile.cpp FatFileLFN.cpp FatFilePrint.cpp FatFileSFN.cpp FatVolume.cpp FmtNumber.cpp fstream.cpp istream.cpp ostream.cpp StdioStream.cpp
    ../Libraries/SdFat/src/SdCard/: SdSpiCard.cpp SdSpiCardEX.cpp
    ../Libraries/SdFat/src/SpiDriver/: SdSpiSTM32.cpp
    ../Libraries/SdFat/src/: MinimumSerial.cpp
  group cm_backtrace
    ../Libraries/cm_backtrace/: cmb_cfg.h cm_backtrace.c
  group ArduinoAPI
    ../ArduinoAPI/: Arduino.c dtostrf.c itoa.c HardwareSerial.cpp Print.cpp Stream.cpp SPI.cpp Tone.cpp Wire.cpp WireBase.cpp WMath.cpp WString.cpp
  group Core
    ../Core/: adc.c delay.c exti.c gpio.c timer.c pwm.c rtc.c extend_SRAM.c
  group README
    ../: README.md
  group CMSIS
    ../Libraries/CMSIS/CM4/DeviceSupport/: system_at32f4xx.c
    ../Libraries/CMSIS/CM4/DeviceSupport/startup/mdk/: startup_at32f403acgu7.s
  group AT32StdPeriph
    ../Libraries/AT32F4xx_StdPeriph_Driver/src/: at32f4xx_acc.c at32f4xx_adc.c at32f4xx_bkp.c at32f4xx_can.c at32f4xx_comp.c at32f4xx_crc.c at32f4xx_dac.c at32f4xx_dbgmcu.c at32f4xx_dma.c at32f4xx_ertc.c at32f4xx_eth.c at32f4xx_exti.c at32f4xx_flash.c at32f4xx_gpio.c at32f4xx_gpio_ex.c at32f4xx_i2c.c at32f4xx_iwdg.c at32f4xx_pwr.c at32f4xx_rcc.c at32f4xx_rtc.c at32f4xx_sdio.c at32f4xx_spi.c at32f4xx_syscfg.c at32f4xx_tim.c at32f4xx_usart.c at32f4xx_wwdg.c at32f4xx_xmc.c misc.c
